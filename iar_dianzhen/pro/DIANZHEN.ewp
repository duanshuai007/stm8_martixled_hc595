# IAR project DIANZHEN.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: D:\stm8\iar_dianzhen\app; D:\stm8\iar_dianzhen\bsp; D:\stm8\iar_dianzhen\cfg; D:\stm8\iar_dianzhen\lib\STM8S_StdPeriph_Driver\inc; D:\stm8\iar_dianzhen
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: DIANZHEN.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group app
    ../app/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group LIB/MY_LIB
    ../app/: AD.c clk_config.c font.h hc138.c hc595.c io_config.c
  group LIB/STM8S_PERIPH
    ../lib/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c stm8s_wwdg.c
