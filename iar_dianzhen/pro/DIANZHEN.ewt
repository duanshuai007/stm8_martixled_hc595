<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data/>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data/>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <file>
      <name>$PROJ_DIR$\..\app\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\stm8s_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\stm8s_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\stm8s_it.h</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
  </group>
  <group>
    <name>CFG</name>
  </group>
  <group>
    <name>LIB</name>
    <group>
      <name>MY_LIB</name>
      <file>
        <name>$PROJ_DIR$\..\app\AD.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\app\clk_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\app\font.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\app\hc138.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\app\hc595.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\app\io_config.c</name>
      </file>
    </group>
    <group>
      <name>STM8S_PERIPH</name>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_adc1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_awu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_beep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_itc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_rst.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_tim1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_tim2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_uart1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\lib\STM8S_StdPeriph_Driver\src\stm8s_wwdg.c</name>
      </file>
    </group>
  </group>
</project>


